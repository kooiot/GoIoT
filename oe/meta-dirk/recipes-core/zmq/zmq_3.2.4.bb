require zmq.inc

SRC_URI[md5sum] = "39af2d41e3fb744b98d7999e291e05dc"
SRC_URI[sha256sum] = "df96a141c85b65c2cb6c0db22223126623a09eecbfccb7f74400f3f938742f59"

